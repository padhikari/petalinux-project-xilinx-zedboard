SRC_URI += "file://user_2020-05-11-19-35-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


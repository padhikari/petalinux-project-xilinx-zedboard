SRC_URI += "file://user_PZ7010_FMC2.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
